# Keil uVision project Queue_List_RTOS.uvprojx, settings and files
target Queue_List_RTOS_Driver (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Queue_List_RTOS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F407xx
  c include: .\Unity\src;.\Unity\extras\fixture\src;..\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./App/: App.c stm_veneers.s ListQueueTest.c QueueListRunner.c
  group Queue
    ../src/: Queue_List.c
  group Unity
    ./Unity/src/: unity.c
    ./Unity/extras/fixture/src/: unity_fixture.c
software components: CMSIS:CORE 4.3.0, Compiler:I/O:STDOUT 1.0.0, Device:Startup 2.4.2, RTOS:uC/OS Common 1.0.0, RTOS:uC/OS Kernel 1.0.0
